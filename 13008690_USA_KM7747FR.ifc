Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 557d7d26-958a-430c-a973-51d69a6ab870, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-05T13:05:05+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13008690_USA_KM7747FR:26774700_USA_13008690_KM7747FR, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 942 mm; Height: 103 mm; Depth: 526 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, Default, z_Miele_Connection_Electric, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 26774700_USA_13008690_KM7747FR; sets with these values: 2
